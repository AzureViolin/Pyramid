# Repository AzureViolin/Pyramid

## KiCad design RGB_HEX/RGB_HEX.kicad_pcb

Board: 2 copper layers, 47.8 x 41.3 mm, 46 parts (3 on the bottom side), 42 nets.

Parts:
C1: 10uF; SM0603_Capa
C2, C3, C4: 100nF; SM0603_Capa
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: LED_RGB; LED_RGB_ComK_SMD5050
D13: DIODE; SOD323
F1: FUSE; SM1206
IC1: ATMEGA328P-M; QFN32
MH1, MH2: CONN_1; Mount_Hole_M2Screw
P1: I2C; grove_4_horizontal
P2: FTDI; SIL-6
P3: ISP; pin_array_3x2
Q1, Q2, Q3, Q4, Q5, Q6: NPN; SOT23
R1, R5: 1.0k 1%; SM0603_Resistor
R2, R6: 1.2k 1%; SM0603_Resistor
R3, R7: 2.1k 1%; SM0603_Resistor
R4: 10k; SM0603_Resistor
R8, R9, R10, R11, R12, R13: 1K; SM0603_Resistor
VAL: Kicad_Puzzlebox_back_l
VAL#2: Kicad_OSHW_front_s
X1: CRYSTAL_MURATA; Murata_CSTCE_3213

Connections:
+5V: C1.1, C2.1, D13.2, IC1.4, IC1.6, IC1.18, P1.3, P2.4, P3.2, R4.2
/2: IC1.32, R8.1
/3PWM: IC1.1, R5.1
/4: IC1.2, R9.1
/5PWM: IC1.9, R6.1
/6PWM: IC1.10, R7.1
/7: IC1.11, R10.1
/8: IC1.12, R11.1
/9PWM: IC1.13, R1.1
/10PWM: IC1.14, R2.1
/11PWM: IC1.15, P3.4, R3.1
/12: IC1.16, P3.1, R12.1
/13: IC1.17, P3.3, R13.1
/B-1: D1.2, D3.2, D5.2, D7.2, D9.2, D11.2, R5.2
/B-2: D2.2, D4.2, D6.2, D8.2, D10.2, D12.2, R1.2
/DTR: C4.2, P2.1
/G-1: D1.6, D3.6, D5.6, D7.6, D9.6, D11.6, R7.2
/G-2: D2.6, D4.6, D6.6, D8.6, D10.6, D12.6, R3.2
/R-1: D1.4, D3.4, D5.4, D7.4, D9.4, D11.4, R6.2
/R-2: D2.4, D4.4, D6.4, D8.4, D10.4, D12.4, R2.2
/RESET: C4.1, IC1.29, P3.5, R4.1
/RX: IC1.30, P2.3
/SCL: IC1.28, P1.1
/SDA: IC1.27, P1.2
/TX: IC1.31, P2.2
/XTAL1: IC1.7, X1.1
/XTAL2: IC1.8, X1.3
GND: C1.2, C2.2, C3.2, F1.1, IC1.3, IC1.5, IC1.21, MH1.1, MH2.1, P1.4, P2.6, P3.6, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, X1.2
unnamed: Q1.1, R8.2
unnamed: Q2.1, R9.2
unnamed: Q3.1, R10.2
unnamed: Q4.1, R11.2
unnamed: Q5.1, R12.2
unnamed: Q6.1, R13.2
unnamed: D13.1, F1.2
unnamed: D5.1, D5.3, D5.5, D6.1, D6.3, D6.5, Q3.3
unnamed: D3.1, D3.3, D3.5, D4.1, D4.3, D4.5, Q2.3
unnamed: D7.1, D7.3, D7.5, D8.1, D8.3, D8.5, Q4.3
unnamed: D1.1, D1.3, D1.5, D2.1, D2.3, D2.5, Q1.3
unnamed: C3.1, IC1.20
unnamed: D11.1, D11.3, D11.5, D12.1, D12.3, D12.5, Q6.3
unnamed: D9.1, D9.3, D9.5, D10.1, D10.3, D10.5, Q5.3

## KiCad design Pyramid_Shield/Pyramid_Shield.kicad_pcb

Parts:
BT1: BLUETOOTH_MODULE
C1, C3: 100nF
C2: 10uF
D1: TVS_DIODE_ESD
D2: GREEN LED
D3: RED LED
P1: IR Rec
P2: Button
P3: RGB HEX
P4: GROVE
P5: IR LED
P6: Metal Shield
P7: CONN_5
P8: CONN_4
P9: CONN_5
Q1: PNP
Q2: MOS_DUAL
R1, R2: 10k
R3: 820R
R4: 1M
R5, R6, R7: 330R
R8: 200R
RP1: 10k

Connections:
+3.3V: BT1.12 (3.3V), C2.1, P9.1, Q2.G1 (G), Q2.G2 (G), R4.2, RP1.5 (R4), RP1.6 (R3)
+5V: P1.3, P3.3, P4.3, P9.2, R2.1, RP1.7 (R2), RP1.8 (R1)
+9V: P5.3, P9.5, R8.1
/BT_RESET: BT1.11 (RESET), C1.1, R4.1
/BT_RX: BT1.2 (UART-RX), Q2.S1 (S), RP1.3
/BT_TX: BT1.1 (UART-TX), Q2.S2 (S), RP1.4
/D2: P4.1, P7.1
/D3: P1.1, P7.2
/D4: P7.3, R7.2
/D5: BT1.24 (PIO[1]), P7.4
/D6: P7.5, R3.2
/HBT_RX: D1.1, P8.1, Q2.D1 (D), RP1.1
/HBT_TX: D1.2, P8.2, Q2.D2 (D), RP1.2
/SCL: P3.1, P8.4
/SDA: P3.2, P8.3
GND: BT1.13 (GND0), BT1.14 (GND1), BT1.21 (GND2), BT1.22 (GND3), C1.2, C2.2, C3.1, D1.3, D2.2 (K), D3.2 (K), P1.4, P2.4, P3.4, P4.4, P5.4, P6.1, P6.2, P6.3, P6.4, P6.5, P6.6, P6.7, P6.8, P6.9, P9.3, P9.4, R1.1
unnamed: C3.2, P2.1, R2.2, R7.1
unnamed: D3.1 (A), R6.2
unnamed: D2.1 (A), R5.2
unnamed: BT1.33 (PIO[10]), R6.1
unnamed: BT1.34 (PIO[11]), R5.1
unnamed: Q1.2 (E), R8.2
unnamed: Q1.1 (B), R3.1
unnamed: P5.1, Q1.3 (C), R1.2

Notes on the sheet:
IR_EMIT
IR_RECEIVE
SERIAL_BLUETOOTH
I2C_RGB_PANEL
BUTTON
Bluetooth Status Indicating
optional

Board: 2 copper layers, 54.4 x 51.3 mm, 29 parts (0 on the bottom side), 24 nets.

Other parts of the board:
VAL: Kicad_Puzzlebox_front_s
VAL#2: Kicad_OSHW_back_s

## KiCad design Pyramid_IR_Module/Pyramid_IR_Module.kicad_pcb

Parts:
D1, D2, D3: LED
MH1: CONN_1
P1: CONN_4
Q1: NPN
R1: 820
R2: 82

Connections:
+9V: P1.3, R2.1
/LED1: D1.1 (A), R2.2
/LED2: D1.2 (K), D2.1 (A)
/LED3: D2.2 (K), D3.1 (A)
/LED4: D3.2 (K), Q1.3 (C)
GND: MH1.1, P1.4, Q1.2 (E)
unnamed: P1.1, R1.1
unnamed: Q1.1 (B), R1.2

Board: 2 copper layers, 20.3 x 9.5 mm, 8 parts (3 on the bottom side), 8 nets.

## Commit log

2013-06-14 Pyramid Electronics Gerber File
2013-06-30 Full electronics in Puzzlebox Pyramid, a mind-control universal infrared remote
2013-06-30 clean up
2013-06-30 add firmware
2013-07-03 add firmware for RGB HEX board
2013-07-03 fixed bugs on NPN and PNP library, IR module and Pyramid Shield
2013-07-10 New Product Importing

Notices in the files:
Pyramid_IR_Module/Pyramid_IR_Module.kicad_pcb:
GPLv2
